# Keil uVision project LeptonM7.uvprojx, settings and files
target LeptonM7 Configuration (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: LeptonM7 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ..\Inc;        ..\Drivers\STM32F7xx_HAL_Driver\Inc;        ..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;        ..\Drivers\CMSIS\Include;        ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c lepton.c functions.c fonts.c touch.c main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
    ../: README.md
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_crc.c stm32f7xx_hal_tim.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_spi.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_crc.c stm32f7xx_hal_tim.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal_spi.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma.c stm32f7xx_ll_fmc.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s startup_stm32f746xx.s
